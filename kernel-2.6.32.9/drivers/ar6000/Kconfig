## kernel-2.6.32.9/drivers/ar6000/Kconfig
```kconfig
config ATH6K_X10
	tristate "Atheros WLAN for X10"
        depends on WLAN_80211
	help
    Build atheros module for X10
```
